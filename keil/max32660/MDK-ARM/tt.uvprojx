# Keil uVision project tt.uvprojx, settings and files
target Target 1 (5050041::5.06 update 6 (build 750)::.\ARMCC)
  device: MAX32660 Maxim
  pack: Maxim.MAX32660.1.2.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tt +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --locale=english
  c include: ..\BSP\Inc;..\Drivers\CMSIS\Include;..\Drivers\Inc;..\Drivers\MAX32660PeriphDriver\Inc;..\Core;..\Drivers\Device\Inc;..\App\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group BSP
    ../BSP/Src/: board.c led.c pb.c stdio.c
  group Drivers
    ../Drivers/MAX32660PeriphDriver/Src/: dma.c flc.c gpio.c i2c.c i2s.c icc.c lp.c mxc_assert.c mxc_delay.c mxc_lock.c mxc_pins.c mxc_sys.c nvic_table.c rtc.c spi.c spi17y.c spimss.c tmr.c tmr_utils.c uart.c
  group MDK-ARM
    ./: startup_max32660.s system_max32660.c
  group Core
    ../Drivers/MAX32660PeriphDriver/Src/: wdt.c
    ../Core/: main.c
  group User/App
    ../App/Src/: algorithm.c gui.c watch.c task_process.c blood.c user_uart.c
  group Drivers/Device
    ../Drivers/Device/Src/: max30100.c st7789.c
